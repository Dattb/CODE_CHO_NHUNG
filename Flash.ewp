# IAR project Flash.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S001J3 STM8S001J3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; User; Lib\inc; Lib
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Flash.hex
  ILINK.IlinkOutputFile: Flash.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Lib
    Lib/src/: RGB_P9414_IC.c stm8s_clk.c stm8s_flash.c stm8s_gpio.c stm8s_tim1.c stm8s_tim2.c
  group User
    User/: main.c stm8s_it.c
